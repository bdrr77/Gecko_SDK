# IAR project em3xx.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: $--bootloader--$; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_$--partNumber;U--$; PHY_EM3XX; CONFIGURATION_HEADER="$--generatedHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\util; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..\..\radio\$--railLibDir--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\..\..\CMSIS\Include; $--halDirFromProjBs--$\..\..\$--deviceDir--$\SiliconLabs\$--chipFamily;L--$\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: $--bootloader--$; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_$--partNumber;U--$; PHY_EM3XX; CONFIGURATION_HEADER="$--generatedHeader--$"; PLATFORM_HEADER="$--halDirFromStackFs--$/micro/cortexm3/compiler/iar.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\util; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\..\..\CMSIS\Include; $--halDirFromProjBs--$\..\..\$--deviceDir--$\SiliconLabs\$--chipFamily;L--$\Include
  OBJCOPY.OOCOutputFile: $--deviceName--$.s37
  prebuild: $--deviceName--$-prebuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' '$--studioInstallationPath--$'
  postbuild: $--deviceName--$-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' '$--studioInstallationPath--$'
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkConfigDefines: $--bootloader--$=1; SIMEEPROM_SIZE=$--simeepromSize--$; PSSTORE_SIZE=$--psstoreSize--$; LONGTOKEN_SIZE=$--longTokenSize--$; HEADER_SIZE=$--headerSize--$
  ILINK.IlinkIcfFile: $--halDirFromProjBs--$\micro\cortexm3\em35x\$--partNumber;L--$\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
